# Keil uVision project bk3435.uvproj, settings and files
target BK3435_app (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3435_ble_app
  AfterMake: fromelf --bin --output .\output\app\bk3435_ble_app.bin .\obj\bk3435_ble_app.axf
  AfterMake: .\output\encrypt_app_usbupdata.bat
  c flags: Optim=4
  c misc: --c99
  c include: .\config;.\app;..\..\sdk\plactform\arch;..\..\sdk\plactform\arch\compiler;..\..\sdk\plactform\arch\ll;..\..\sdk\plactform\arch\boot;..\..\sdk\plactform\arch\main;..\..\sdk\plactform\driver\pwm;..\..\sdk\plactform\driver\adc;..\..\sdk\plactform\driver\audio;..\..\sdk\plactform\driver\wdt;..\..\sdk\plactform\driver\rtc;..\..\sdk\plactform\driver\i2c;..\..\sdk\plactform\driver\utc;..\..\sdk\plactform\driver\ir;..\..\sdk\plactform\driver\spi;..\..\sdk\plactform\driver\plf;..\..\sdk\plactform\driver\counter;..\..\sdk\plactform\driver\gpio;..\..\sdk\plactform\driver\intcntl;..\..\sdk\plactform\driver\icu;..\..\sdk\plactform\driver\intc;..\..\sdk\plactform\driver\flash;..\..\sdk\plactform\driver\timer;..\..\sdk\plactform\driver\reg;..\..\sdk\plactform\driver\uart;..\..\sdk\plactform\driver\emi;..\..\sdk\ble_stack\central\com\rwble;..\..\sdk\ble_stack\central\com\rwble_hl;..\..\sdk\ble_stack\central\com\rwble;..\..\sdk\ble_stack\central\com\rwip\api;..\..\sdk\ble_stack\central\com\rwble_hl;..\..\sdk\ble_stack\central\src;..\..\sdk\plactform\reg;..\..\sdk\plactform\driver\syscntl;..\..\sdk\plactform\rom\hci;..\..\sdk\ble_stack\central\inc;..\..\sdk\ble_stack\central\inc\hci;..\..\sdk\ble_stack\central\inc\h4tl;..\..\sdk\ble_stack\central\inc\ke;..\..\sdk\ble_stack\central\inc\nvds;..\..\sdk\ble_stack\central\inc\ea;..\..\sdk\ble_stack\central\inc\em;..\..\sdk\ble_stack\central\inc\ahi;..\..\sdk\ble_stack\central\inc\ble\hl\gap\gapc;..\..\sdk\ble_stack\central\inc\ble\hl\gap\gapm;..\..\sdk\ble_stack\central\inc\ble\hl\gap\smpc;..\..\sdk\ble_stack\central\inc\ble\hl\gap\smpm;..\..\sdk\ble_stack\central\inc\ble\hl\gatt\attc;..\..\sdk\ble_stack\central\inc\ble\hl\gatt\attm;..\..\sdk\ble_stack\central\inc\ble\hl\gatt\atts;..\..\sdk\ble_stack\central\inc\ble\hl\gatt\gattc;..\..\sdk\ble_stack\central\inc\ble\hl\gatt\gattm;..\..\sdk\ble_stack\central\inc\ble\hl\l2c\l2cc;..\..\sdk\ble_stack\central\inc\ble\hl\l2c\l2cm;..\..\sdk\ble_stack\central\inc\ble\ll\em;..\..\sdk\ble_stack\central\inc\ble\ll\llc;..\..\sdk\ble_stack\central\inc\ble\ll\lld;..\..\sdk\ble_stack\central\inc\ble\ll\llm;..\..\sdk\ble_stack\central\com\rwip\api;..\..\sdk\ble_stack\central\inc\ble\hl\gap;..\..\sdk\ble_stack\central\inc\ble\hl\gatt;..\..\sdk\ble_stack\common\prf;..\..\sdk\ble_stack\common\profiles\dis\diss\src;..\..\sdk\ble_stack\common\profiles\bas\bass\src;..\..\sdk\ble_stack\common\profiles\ancs\ancsc\api;..\..\sdk\ble_stack\common\profiles\ancs\ancsc\src;..\..\sdk\ble_stack\common\profiles\ancs;..\..\sdk\ble_stack\common\profiles\FCC0\api;..\..\sdk\ble_stack\common\profiles\FCC0\src;..\..\sdk\ble_stack\common\profiles\FCC0\util;..\..\sdk\ble_stack\common\profiles\FEE0\api;..\..\sdk\ble_stack\common\profiles\FEE0\src;..\..\sdk\ble_stack\common\profiles\hogp;..\..\sdk\ble_stack\common\profiles\hogp\hogpd\api;..\..\sdk\ble_stack\common\profiles\hogp\hogpd\src;..\..\libs;..\..\sdk\ble_stack\common\profiles\wechat\api;..\..\sdk\ble_stack\common\profiles\wechat\src;.\wechat;..\..\sdk\ble_stack\common\profiles\bas\bass;..\..\sdk\ble_stack\common\profiles\bas\bass\api;..\..\sdk\ble_stack\common\profiles\dis\diss;..\..\sdk\ble_stack\common\profiles\dis\diss\api;..\..\sdk\ble_stack\common\profiles\FFF0\api;..\..\sdk\ble_stack\common\profiles\FFF0;..\..\sdk\ble_stack\common\profiles\oad\api;..\..\sdk\ble_stack\common\profiles\sdp\api;..\..\sdk\ble_stack\common\profiles\sdp\src;..\..\sdk\plactform\com\api;..\..\sdk\plactform\driver\rf;..\..\sdk\ble_stack\central\com\rwble;..\..\sdk\ble_stack\central\com\rwble_hl;..\..\sdk\ble_stack\central\com\rwip\api;..\..\sdk\ble_stack\central\inc\dbg;..\..\sdk\plactform\util;..\..\sdk\plactform\driver\usb;..\..\sdk\plactform\driver\usb\include;..\..\sdk\plactform\driver\usb\include\class;..\..\sdk\plactform\driver\usb\src\cd;..\..\sdk\plactform\driver\usb\src\drivers\comm;..\..\sdk\plactform\driver\usb\src\drivers\msd;..\..\sdk\plactform\driver\usb\src\examples;..\..\sdk\plactform\driver\usb\src\functions\trans_fn;..\..\sdk\plactform\driver\usb\src\systems\none;..\..\sdk\plactform\driver\usb\src\systems\none\afs;..\..\sdk\plactform\driver\usb\src\test;..\..\sdk\plactform\driver\usb\src\test\msd;..\..\sdk\ble_stack\central\com\prf;..\..\sdk\ble_stack\common\profiles\dis\disc\api;.\device\fall_sensor\algo;.\device\fall_sensor\data;.\device\fall_sensor\drv\gsensor_pressure;.\device\uart_data;..\..\sdk\plactform\driver\uart2
  asm include: .\src\plf\refip\src\arch\ll
  library: MicroLIB
  scatter file: ..\..\sdk\project_files\central_link_app_usbupdata.txt
  link misc: --entry sys_Reset
  group System
    ../../sdk/plactform/arch/boot/: boot_handlers.s boot_vectors.s
    ../../sdk/plactform/driver/intc/: intc.c
    ../../sdk/project_files/: central_stack_symbol.txt
    ./app/: arch_main.c
  group config
    ./config/: rwapp_config.h rwip_config.h rwprf_config.h user_config.h
    ../../sdk/ble_stack/central/com/rwble/: rwble_config.h
  group ip
    ../../sdk/ble_stack/central/com/rwble/: rwble.c
    ../../sdk/ble_stack/central/com/rwble_hl/: rwble_hl.c
    ../../sdk/ble_stack/central/com/rwip/src/: rwip.c
  group driver
    ../../sdk/plactform/driver/flash/: flash.c
    ../../sdk/plactform/driver/gpio/: gpio.c
    ../../sdk/plactform/driver/icu/: icu.c
    ../../sdk/plactform/driver/syscntl/: syscntl.c
    ../../sdk/plactform/driver/timer/: timer.c
    ../../sdk/plactform/driver/uart/: uart.c
    ../../sdk/plactform/driver/utc/: utc_clock.c
    ../../sdk/plactform/driver/wdt/: wdt.c
    ../../sdk/plactform/driver/emi/: emi.c
    ../../sdk/plactform/driver/rf/: rf_xvr.c
  group profile
    ../../sdk/ble_stack/common/profiles/sdp/src/: sdp_service.c sdp_service_task.c
    ../../sdk/ble_stack/central/com/prf/: prf_utils.c prf.c
  group app
    ./app/: app.c app_sdp.c app_task.c central_api.c app_sec.c app_wlist.c
  group util
    ../../sdk/plactform/util/: enc_key.c util_encrypt.c
  group lib
    ../../libs/: bk3435_pn9_mode.lib bk3435_fcc_mode.lib sbc_decoder.c sbc_common.c
  group usb
    ../../sdk/plactform/driver/usb/: driver_usb.c
    ../../sdk/plactform/driver/usb/src/cd/: mu_cntlr.c mu_descs.c mu_drc.c mu_fadma.c mu_fc.c mu_fdr.c mu_fun.c mu_funex.c mu_hc.c mu_hdr.c mu_hst.c mu_list.c mu_pip.c
    ../../sdk/plactform/driver/usb/src/drivers/msd/: mu_mapi.c mu_mbot.c mu_mscsi.c
    ../../sdk/plactform/driver/usb/src/examples/msd/: mu_msdfn.c
    ../../sdk/plactform/driver/usb/src/functions/trans_fn/: mu_tfunc.c
    ../../sdk/plactform/driver/usb/src/lib/: mu_bits.c mu_ramfl.c mu_stack.c mu_stdio.c mu_strng.c
    ../../sdk/plactform/driver/usb/src/systems/none/: plat_uds.c
    ../../sdk/plactform/driver/usb/src/systems/none/afs/: board.c
    ../../sdk/plactform/driver/usb/src/test/msd/: tst_msd.c
  group device
    ./device/fall_sensor/algo/: alpsfall.c calSleepTime.c stepFall.c
    ./device/fall_sensor/data/: fall_sensor_data.c
    ./device/fall_sensor/drv/gsensor_pressure/: hscdhd003a.c hsppad042a.c
    ./device/uart_data/: ble_to_MTK_protocol.c uart_data.c
    ../../sdk/plactform/driver/uart2/: uart2.c
